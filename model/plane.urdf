Commit message: update rsl_rl

File: model/plane.urdf (robot description, URDF)
Before this commit: robot plane, 1 links, 0 joints
Links:
- link planeLink: mass .0 -> 1.0; geometry collision box size=200 200 10; visual mesh filename=plane100.obj scale=1 1 1
